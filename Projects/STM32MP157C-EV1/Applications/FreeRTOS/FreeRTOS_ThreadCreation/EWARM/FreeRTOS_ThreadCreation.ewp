# IAR project FreeRTOS_ThreadCreation.ewp, settings and files
configuration FreeRTOS_ThreadCreation (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32MP157Cxx; CORE_CM4
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Drivers/BSP/STM32MP15xx_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Templates.hex
  ILINK.IlinkOutputFile: FreeRTOS_ThreadCreation.elf
  ILINK.IlinkIcfFile: stm32mp15xx_m4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: copro_sync.c lock_resource.c main.c stm32mp1xx_hal_msp.c stm32mp1xx_hal_timebase_tim.c stm32mp1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32MP15xx_EVAL
    ../../../../../../Drivers/BSP/STM32MP15xx_EVAL/: stm32mp15xx_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Drivers/Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Drivers/Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
