# Keil uVision project OpenAMP_for_signed_fw.uvprojx, settings and files
target OpenAMP_for_signed_fw (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.1.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: OpenAMP_for_signed_fw +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,NO_ATOMIC_64_SUPPORT,USE_HAL_DRIVER,STM32MP157Cxx,METAL_INTERNAL,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,VIRTIO_SLAVE_ONLY,__LOG_TRACE_IO_
  c include: ../Inc;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver;../../../../../../Drivers/BSP/STM32MP15xx_DISCO;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include;../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ./: startup_stm32mp15xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: openamp_log.c main.c mbox_ipcc.c openamp.c rsc_table.c lock_resource.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_exti.c
  group Middlewares/OpenAMP/libmetal
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
  group Middlewares/OpenAMP/libmetal/generic
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c generic_device.c generic_init.c generic_io.c generic_shmem.c time.c irq.c
  group Middlewares/OpenAMP/libmetal/generic/template
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/template/: sys.c
  group Middlewares/OpenAMP/virtual_driver
    ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver/: virt_uart.c
  group Middlewares/OpenAMP/open-amp/remoteproc
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
  group Middlewares/OpenAMP/open-amp/rpmsg
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtqueue.c virtio.c
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
  group Middlewares/OpenAMP/open-amp/virtio
    ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver/: virt_uart.h
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDOUT 1.2.0
