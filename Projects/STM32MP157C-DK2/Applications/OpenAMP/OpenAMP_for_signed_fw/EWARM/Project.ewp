# IAR project Project.ewp, settings and files
configuration OpenAMP_for_signed_fw (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; NO_ATOMIC_64_SUPPORT; USE_HAL_DRIVER; STM32MP157Cxx; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; __LOG_TRACE_IO_
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver; ../../../../../../Drivers/BSP/STM32MP15xx_DISCO; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenAMP_for_signed_fw.hex
  ILINK.IlinkOutputFile: OpenAMP_for_signed_fw.out
  ILINK.IlinkIcfFile: stm32mp15xx_retram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: lock_resource.c main.c mbox_ipcc.c openamp.c openamp_log.c rsc_table.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c
  group Middlewares/OpenAMP/libmetal
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
  group Middlewares/OpenAMP/libmetal/generic
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c generic_device.c generic_init.c generic_io.c generic_shmem.c time.c
  group Middlewares/OpenAMP/libmetal/generic/template
    ../../../../../../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/template/: sys.c
  group Middlewares/OpenAMP/open-amp/remoteproc
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
  group Middlewares/OpenAMP/open-amp/rpmsg
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
  group Middlewares/OpenAMP/open-amp/virtio
    ../../../../../../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
  group Middlewares/OpenAMP/virtual_driver
    ../../../../../../Middlewares/Third_Party/OpenAMP/virtual_driver/: virt_uart.c
