# Keil uVision project FreeRTOS_ThreadCreation.uvprojx, settings and files
target FreeRTOS_ThreadCreation (6220000::V6.22::ARMCLANG)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.1
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: FreeRTOS_ThreadCreation +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Cxx
  c include: ../Inc;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32MP15xx_DISCO;../../../../../../Utilities/ResourcesManager
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: stm32mp15xx_m4.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../: readme.txt
    ./: startup_stm32mp15xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: lock_resource.c copro_sync.c main.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c stm32mp1xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_ipcc.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
