# IAR project Project.ewp, settings and files
configuration FreeRTOS_ThreadCreation (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32MP157Cxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32MP15xx_DISCO; ../../../../../../Utilities/ResourcesManager
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: FreeRTOS_ThreadCreation.hex
  ILINK.IlinkOutputFile: FreeRTOS_ThreadCreation.out
  ILINK.IlinkIcfFile: stm32mp15xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: copro_sync.c lock_resource.c main.c stm32mp1xx_hal_msp.c stm32mp1xx_hal_timebase_tim.c stm32mp1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Remoteproc
    ../Remoteproc/: fw_cortex_m4.sh README
