# IAR project Project.ewp, settings and files
configuration ADC_SingleConversion_TriggerTimer_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32MP157Cxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/BSP/STM32MP15xx_DISCO; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_SingleConversion_TriggerTimer_DMA.hex
  ILINK.IlinkOutputFile: ADC_SingleConversion_TriggerTimer_DMA.out
  ILINK.IlinkIcfFile: stm32mp15xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: lock_resource.c main.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c stm32mp15xx_disco_bus.c stm32mp15xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
