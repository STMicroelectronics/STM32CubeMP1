# IAR project Project.ewp, settings and files
configuration UART_Receive_Transmit_Console (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; __LOG_TRACE_IO_; USE_HAL_DRIVER; STM32MP157Cxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/BSP/STM32MP15xx_DISCO; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_Receive_Transmit_Console.hex
  ILINK.IlinkOutputFile: UART_Receive_Transmit_Console.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: lock_resource.c main.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c
